# Keil uVision project lpc802_bl.uvprojx, settings and files
target plc8xx (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC802M001JDH16 NXP
  pack: NXP.LPC802_DFP.16.0.0
  cpu: IROM(0x00000000,0x00004000) IRAM(0x10000000,0x00000800) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lpc802_bl +hex
  AfterMake: $KARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x0)
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c define: LPC802 __VTOR_PRESENT LIB_DEBUG
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\inc;..\..\..\..\Libraries\drivers_lpc800\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src;..\src\config;..\..\..\..\Libraries\utilities\mcuboot;..\..\..\..\Libraries\utilities\kptl
  asm define: RAM_TARGET
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x10000000 size 0x7f0
  group startup_lpc8xx
    ../../../../Libraries/startup/src/: system_LPC8xx.c
    ../../../../Libraries/startup/src/mdk/: startup_LPC8xx.s
  group user
    ../src/: main.c
  group user\config
    ../src/config/: bl_cfg.h
  group drivers_lpc800
    ../../../../Libraries/drivers_lpc800/src/: common.c gpio.c syscon.c uart.c flash.c
  group utilities\mcuboot
    ../../../../Libraries/utilities/mcuboot/: mcuboot.c
  group utilities\kptl
    ../../../../Libraries/utilities/kptl/: kptl.c
